<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mdsx710_rcvr</value></param>
<param><key>title</key><value>MDS x710 Receiver</value></param>
<param><key>author</key><value>Karl Koscher</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>scada</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>3540</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>76923</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_1</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>scada.filters.cosine_filter(1.0/3, 8, 351, True)</value></param>
</block>
<block>
<key>scada_mdsx710_decode</key>
<param><key>id</key><value>scada_mdsx710_decode_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>in</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_1</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>scada_mdsx710_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>scada_mdsx710_decode_0</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
